# IAR project template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT32A423VCT7_v2 ArteryTek AT32A423VCT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32A423VCT7; USE_STDPERIPH_DRIVER; AT_START_A423_V1
  ICCARM.CCIncludePath2: ..\..\libraries\drivers\inc; ..\..\libraries\cmsis\cm4\core_support; ..\..\libraries\cmsis\cm4\device_support; ..\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Template.hex
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkIcfFile: AT32A423xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group cmsis
    ./: startup_at32a423.s
    ../../libraries/cmsis/cm4/device_support/: system_at32a423.c
  group firmware
    ../../libraries/drivers/src/: at32a423_acc.c at32a423_adc.c at32a423_can.c at32a423_crc.c at32a423_crm.c at32a423_dac.c at32a423_debug.c at32a423_dma.c at32a423_ertc.c at32a423_exint.c at32a423_flash.c at32a423_gpio.c at32a423_i2c.c at32a423_misc.c at32a423_pwc.c at32a423_scfg.c at32a423_spi.c at32a423_tmr.c at32a423_usart.c at32a423_usb.c at32a423_wdt.c at32a423_wwdt.c at32a423_xmc.c
  group user
    ../src/: at32a423_int.c at32a423_wk_config.c main.c
