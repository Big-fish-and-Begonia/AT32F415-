# Keil uVision project template.uvproj, settings and files
target tempate (ARM-ADS)
  device: AT32A423VCT7 ArteryTek
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x400000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: AT32A423VCT7,USE_STDPERIPH_DRIVER,AT_START_A423_V1
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3f0000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group user
    ../src/: at32a423_int.c at32a423_wk_config.c main.c
  group firmware
    ../../libraries/drivers/src/: at32a423_acc.c at32a423_adc.c at32a423_can.c at32a423_crc.c at32a423_crm.c at32a423_dac.c at32a423_debug.c at32a423_dma.c at32a423_ertc.c at32a423_exint.c at32a423_flash.c at32a423_gpio.c at32a423_i2c.c at32a423_misc.c at32a423_pwc.c at32a423_scfg.c at32a423_spi.c at32a423_tmr.c at32a423_usart.c at32a423_usb.c at32a423_wdt.c at32a423_wwdt.c at32a423_xmc.c
  group cmsis
    ../../libraries/cmsis/cm4/device_support/: system_at32a423.c
    ./: startup_at32a423.s
