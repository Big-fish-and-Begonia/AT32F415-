# Keil uVision project template.uvprojx, settings and files
target template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32WB415CCU7-7 ArteryTek
  pack: ArteryTek.AT32WB415_DFP.2.0.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32WB415CCU7-7,USE_STDPERIPH_DRIVER
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../src/: main.c at32wb415_wk_config.c at32wb415_int.c
  group firmware
    ../../libraries/drivers/src/: at32wb415_adc.c at32wb415_can.c at32wb415_cmp.c at32wb415_crc.c at32wb415_crm.c at32wb415_debug.c at32wb415_dma.c at32wb415_ertc.c at32wb415_exint.c at32wb415_flash.c at32wb415_gpio.c at32wb415_i2c.c at32wb415_misc.c at32wb415_pwc.c at32wb415_spi.c at32wb415_tmr.c at32wb415_usart.c at32wb415_usb.c at32wb415_wdt.c at32wb415_wwdt.c
  group cmsis
    ../../libraries/cmsis/cm4/device_support/: system_at32wb415.c
    ./: startup_at32wb415.s
