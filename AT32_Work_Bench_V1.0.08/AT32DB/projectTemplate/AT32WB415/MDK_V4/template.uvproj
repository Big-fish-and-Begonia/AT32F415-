# Keil uVision project template.uvproj, settings and files
target tempate (ARM-ADS)
  device: -AT32WB415CCU7-7 ArteryTek
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x08000000-0x0803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4")
  output: Template +hex
  c flags: Optim=1
  c define: AT32WB415CCU7_7,USE_STDPERIPH_DRIVER
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../src/: main.c at32wb415_wk_config.c at32wb415_int.c
  group firmware
    ../../libraries/drivers/src/: at32wb415_adc.c at32wb415_can.c at32wb415_cmp.c at32wb415_crc.c at32wb415_crm.c at32wb415_debug.c at32wb415_dma.c at32wb415_ertc.c at32wb415_exint.c at32wb415_flash.c at32wb415_gpio.c at32wb415_i2c.c at32wb415_misc.c at32wb415_pwc.c at32wb415_spi.c at32wb415_tmr.c at32wb415_usart.c at32wb415_usb.c at32wb415_wdt.c at32wb415_wwdt.c
  group cmsis
    ../../libraries/cmsis/cm4/device_support/: system_at32wb415.c
    ./: startup_at32wb415.s
