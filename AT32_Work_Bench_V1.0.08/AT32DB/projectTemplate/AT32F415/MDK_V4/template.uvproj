# Keil uVision project template.uvproj, settings and files
target tempate (ARM-ADS)
  device: -AT32F415RCT7 ArteryTek
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x08000000-0x0803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4")
  output: Template +hex
  c flags: Optim=1
  c define: AT32F415RCT7,USE_STDPERIPH_DRIVER
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../src/: main.c at32f415_wk_config.c at32f415_int.c
  group firmware
    ../../libraries/drivers/src/: at32f415_adc.c at32f415_can.c at32f415_cmp.c at32f415_crc.c at32f415_crm.c at32f415_debug.c at32f415_dma.c at32f415_ertc.c at32f415_exint.c at32f415_flash.c at32f415_gpio.c at32f415_i2c.c at32f415_misc.c at32f415_pwc.c at32f415_sdio.c at32f415_spi.c at32f415_tmr.c at32f415_usart.c at32f415_usb.c at32f415_wdt.c at32f415_wwdt.c
  group cmsis
    ../../libraries/cmsis/cm4/device_support/: system_at32f415.c
    ./: startup_at32f415.s
