# IAR project template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT32A403AVGT7_v2 ArteryTek -AT32A403AVGT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32A403AVGT7; USE_STDPERIPH_DRIVER; AT_START_A403A_V1
  ICCARM.CCIncludePath2: ..\..\libraries\drivers\inc; ..\..\libraries\cmsis\cm4\core_support; ..\..\libraries\cmsis\cm4\device_support; ..\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.hex
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkIcfFile: AT32A403AxG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group cmsis
    ./: startup_at32a403a.s
    ../../libraries/cmsis/cm4/device_support/: system_at32a403a.c
  group firmware
    ../../libraries/drivers/src/: at32a403a_acc.c at32a403a_adc.c at32a403a_bpr.c at32a403a_can.c at32a403a_crc.c at32a403a_crm.c at32a403a_dac.c at32a403a_debug.c at32a403a_dma.c at32a403a_exint.c at32a403a_flash.c at32a403a_gpio.c at32a403a_i2c.c at32a403a_misc.c at32a403a_pwc.c at32a403a_rtc.c at32a403a_sdio.c at32a403a_spi.c at32a403a_tmr.c at32a403a_usart.c at32a403a_usb.c at32a403a_wdt.c at32a403a_wwdt.c at32a403a_xmc.c
  group user
    ../src/: at32a403a_int.c at32a403a_wk_config.c main.c rtc.c
