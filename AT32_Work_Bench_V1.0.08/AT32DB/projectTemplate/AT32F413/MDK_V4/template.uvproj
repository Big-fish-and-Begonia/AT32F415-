# Keil uVision project template.uvproj, settings and files
target tempate (ARM-ADS)
  device: -AT32F413RCT7 ArteryTek
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x08000000-0x0803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Template +hex
  c flags: Optim=1
  c define: AT32F413RCT7,USE_STDPERIPH_DRIVER
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ../src/: main.c at32f413_wk_config.c at32f413_int.c rtc.c
  group firmware
    ../../libraries/drivers/src/: at32f413_acc.c at32f413_adc.c at32f413_bpr.c at32f413_can.c at32f413_crc.c at32f413_crm.c at32f413_debug.c at32f413_dma.c at32f413_exint.c at32f413_flash.c at32f413_gpio.c at32f413_i2c.c at32f413_misc.c at32f413_pwc.c at32f413_rtc.c at32f413_sdio.c at32f413_spi.c at32f413_tmr.c at32f413_usart.c at32f413_usb.c at32f413_wdt.c at32f413_wwdt.c
  group cmsis
    ./: startup_at32f413.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f413.c
