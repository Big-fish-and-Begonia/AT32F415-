# IAR project template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT32F425R8T7_v2 ArteryTek -AT32F425R8T7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: AT32F425R8T7; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\libraries\drivers\inc; ..\..\libraries\cmsis\cm4\core_support; ..\..\libraries\cmsis\cm4\device_support; ..\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.hex
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: AT32F425x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group cmsis
    ./: startup_at32f425.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f425.c
  group firmware
    ../../libraries/drivers/src/: at32f425_acc.c at32f425_adc.c at32f425_can.c at32f425_crc.c at32f425_crm.c at32f425_debug.c at32f425_dma.c at32f425_ertc.c at32f425_exint.c at32f425_flash.c at32f425_gpio.c at32f425_i2c.c at32f425_misc.c at32f425_pwc.c at32f425_scfg.c at32f425_spi.c at32f425_tmr.c at32f425_usart.c at32f425_usb.c at32f425_wdt.c at32f425_wwdt.c
  group user
    ../src/: at32f425_int.c at32f425_wk_config.c main.c
