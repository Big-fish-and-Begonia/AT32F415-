# Keil uVision project F415.uvprojx, settings and files
target F415 (5060960::V5.06 update 7 (build 960)::.\ARMV5)
  device: -AT32F415CBT7 ArteryTek
  pack: ArteryTek.AT32F415_DFP.2.1.4
  cpu: IRAM(0x20000000,0x2000000) IROM(0x08000000,0x8000000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: F415 +hex
  AfterMake: keil-build-viewer.exe
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F415CBT7,USE_STDPERIPH_DRIVER
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\src;..\MDK_V5
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../src/: main.c at32f415_wk_config.c at32f415_int.c
    ./: value.c value.h delay.c delay.h W5500.c w5500.h
  group firmware
    ../../libraries/drivers/src/: at32f415_crc.c at32f415_crm.c at32f415_debug.c at32f415_ertc.c at32f415_exint.c at32f415_flash.c at32f415_gpio.c at32f415_i2c.c at32f415_misc.c at32f415_pwc.c at32f415_spi.c at32f415_tmr.c at32f415_usart.c at32f415_usb.c at32f415_dma.c
  group cmsis
    ../../libraries/cmsis/cm4/device_support/: system_at32f415.c
    ./: startup_at32f415.s
